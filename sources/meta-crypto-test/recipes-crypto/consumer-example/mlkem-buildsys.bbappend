# SPDX-License-Identifier: Apache-2.0 OR ISC OR MIT

MLKEM_PARAMETER_SET = "512"
MLKEM_MULTILEVEL = "1"
MLK_CONFIG_NO_RANDOMIZED_API = "1"